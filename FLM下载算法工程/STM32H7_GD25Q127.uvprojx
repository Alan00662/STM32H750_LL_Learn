# Keil uVision project STM32H7_GD25Q127.uvprojx, settings and files
target STM32H7_GD25Q127 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TX15_LL_ExtFlash_16M
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\MPU;.\HARDWARE\QSPI;.\SYSTEM;.\HARDWARE\W25QXX;..\QSIP_W25QXX_Template-H7;..\W25Q128_QSPI_Keil烧写算法
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: ROM 0x30000000 size 0x48000
  memory RVCT7: ROM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Hardwere
    ./HARDWARE/QSPI/: qspi.c
    ./HARDWARE/W25QXX/: norflash.c
  group SYSTEM
    ./SYSTEM/sys/: sys.c
